# Keil uVision project binary_template.uvproj, settings and files
target Binary_Template-STM32072B-EVAL (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32072B-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\\STM32F0xx\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c4 size 0x3f3c
  group User
    ../src/: app.c stm32_it.c
  group STM32072B-EVAL
    ../../../../Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_crs.c
  group STM32F0XX
    ../src/: system_stm32f0xx.c
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
