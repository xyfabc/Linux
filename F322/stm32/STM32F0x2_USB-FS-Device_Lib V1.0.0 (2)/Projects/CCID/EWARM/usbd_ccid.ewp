# IAR project usbd_ccid.ewp, settings and files
configuration STM32072B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F052VB ST STM32F052VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM32072B_EVAL; USE_STDPERIPH_DRIVER; STM32F072
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\ccid\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32052B-EVAL_usbd_ccid.hex
  ILINK.IlinkOutputFile: STM32072B-EVAL_USBD.out
  ILINK.IlinkIcfFile: stm32f072_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c sc_itf.c smartcard.c stm32_it.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
  group STM32_USB_Device_Library/Class/CCID
    ../../../Libraries/STM32_USB_Device_Library/Class/ccid/src/: usbd_ccid_cmd.c usbd_ccid_core.c usbd_ccid_if.c
  group STM32_USB_Device_Library/Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library/Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072.s
    ../src/: system_stm32f0xx.c
  group STM32F0XX/STM32072B-EVAL
    ../../../Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c
  group STM32F0XX/STM32F072_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
