# Keil uVision project usbd_audio.uvproj, settings and files
target USBD_AUDIO-STM32072B-EVAL (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM32072B_EVAL,USE_STDPERIPH_DRIVER,STM32F072,__WAV_ADDON__
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\audio\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL;..\..\..\Utilities\STM32_Audio\Common;..\..\..\Utilities\STM32_Audio\Addons;..\..\..\Utilities\STM32_Audio\STM32072B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ../src/: app.c stm32_it.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c
  group USB_Class
    ../../../Libraries/STM32_USB_Device_Library/Class/audio/src/: usbd_audio_core.c
  group USB_Drivers
    ../../../Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F0XX
    ../src/: system_stm32f0xx.c
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group STM32072B-EVAL
    ../../../Utilities/STM32_Audio/STM32072B_EVAL/: stm32072b_audio_codec.c
    ../../../Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c
  group STM32F072_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_dac.c stm32f0xx_tim.c
  group STM32_Audio
    ../../../Utilities/STM32_Audio/Common/: stm32_audio_out_if.c
    ../../../Utilities/STM32_Audio/Addons/: wavaddon.c
